LICENSE = "MIT"
IMAGE_FEATURES += "splash "
inherit core-image

require aero-base.inc
