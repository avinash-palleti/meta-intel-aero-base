LICENSE = "MIT"
IMAGE_FEATURES += "splash"
inherit core-image

CORE_IMAGE_EXTRA_INSTALL += "docker"
